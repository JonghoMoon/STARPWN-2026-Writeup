options:
  parameters:
    generate_options: qt_gui
    id: g2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/user/starpwn/Glittercity-OST2/call2.soft
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/user/starpwn/Glittercity-OST2/call2.wav
    repeat: 'False'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '128'
    srate: '300'
    type: float
  states: {}
- name: satellites_afsk_demodulator_0
  id: satellites_afsk_demodulator
  parameters:
    af_carrier: '11080'
    baudrate: '300'
    deviation: '-1000'
    samp_rate: samp_rate
  states: {}

connections:
- [blocks_throttle2_0, '0', satellites_afsk_demodulator_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle2_0, '0']
- [satellites_afsk_demodulator_0, '0', blocks_file_sink_0, '0']
- [satellites_afsk_demodulator_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
